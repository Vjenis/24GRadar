# Keil uVision project iSO-STM32.uvprojx, settings and files
target 24GRadar (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\Key;..\..\User\lcd;..\..\User\SysTick;..\..\User\BGT24MTR12;..\..\User\StmFlash;..\..\User\ADF4158;..\..\User\bsp_clk
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/Key/: bsp_exti.c
    ../../User/Led/: bsp_led.c
    ../../User/lcd/: ascii.h bsp_ili9341_lcd.c bsp_ili9341_lcd.h bsp_lcd.c bsp_lcd.h bsp_xpt2046_lcd.c bsp_xpt2046_lcd.h
    ../../User/SysTick/: bsp_SysTick.h bsp_SysTick.c
    ../../User/BGT24MTR12/: BGT24MTR12.h BGT24MTR12.c
    ../../User/StmFlash/: stm_flash.h stm_flash.c
    ../../User/ADF4158/: bsp_adf4158.h bsp_adf4158.c
    ../../User/bsp_clk/: bsp_clkconfig.h bsp_clkconfig.c
software components: CMSIS:CORE 4.1.0
