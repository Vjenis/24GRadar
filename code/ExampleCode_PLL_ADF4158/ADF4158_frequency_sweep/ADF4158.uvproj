# Keil uVision project ADF4158.uvproj, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ADuC7026 Analog Devices
  cpu: IRAM(0x10000-0x11FFF) IROM(0x80000-0x8F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: ADF4158 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x80000 size 0xf800
  memory RVCT9: RAM 0x10000 size 0x2000
  group Source Group 1
    ./: ADuC702x.s ADF4158_IO.C ADuC7026Driver.c irq_arm.c main.c
